# Repository tjb803/gsa-diamond1

File README.md:

# gsa-diamond1

## Simple Stereo Hi-Fi Amplifier

This is a simple Hi-Fi Stereo amplifier project. The intention 
of the project is to produce something that is simple for
anyone to build without special tools, yet can both sound good
and look good.

Please take a look at the project pages [link TBD] for more details
and pictures of completed examples.

The project is based around the Texas Instruments LM1876
single chip amplifier with a pre-amp section providing a volume 
and balance control and push-button selection of up to four 
input sources and standby mode.

### Project Structure

The project schematics and PCBs are generated with
[KiCad](http://kicad-pcb.org/) v5.x

This project is built on four separate PCBs, so the layout and 
structure of the KiCad files needs a little explanation.

* `gsa-diamond1/`  
  This is the project root.  The important files include:
  * `gsa-d1.pro`  
     The main KiCad project control file.

  * `gsa-d1.sch`  
     The schematic for the whole project. This includes a 
     hierarchical subsheet for each PCB. The subsheets themselves
     are stored in a set of subdirectories and can be processed 
     as separate single-PCB projects.

  * `gsa-d1-pcb.kicad_pcb`  
     An outline PCB that can be used to combine the three main
     project PCBs into single 100x100mm board for production.

* `gsa-diamond1/p-amp/`  
   Files for the _Power Amp_ part of the project. Includes the 
   schematic subsheet (written from the main project schematic) and 
   the netlist and PCB specific to this assembly.

* `gsa-diamond1/c-pre/`  
   Files for the _Pre Amp Controls_ part of the project. Includes the 
   schematic subsheet (written from the main project schematic) and 
   the netlist and PCB specific to this assembly.

* `gsa-diamond1/s-inp/`  
   Files for the _Input Selector_ part of the project. Includes the 
   schematic subsheet (written from the main project schematic) and 
   the netlist and PCB specific to this assembly.

* `gsa-diamond1/v-pwr/`  
   Files for the _Power Supply_ part of the project. Includes the 
   schematic subsheet (written from the main project schematic) and 
   the netlist and PCB specific to this assembly.
  
_**Note:**_ To generate the netlists that are specific for just one 
of the sub-PCBs, it is necessary to open **eeschema** directly against
the schematic for that subsheet; the main KiCad project manager 
cannot be used for this.

### Prerequisites

The KiCad schematics and board layouts use only symbols and
footprints from the [gsa-lib](https://github.com/tjb803/gsa-lib)
project.  You should install and configure that project first,
ensuring you have the latest version that supports KiCad v5.

## KiCad design v-pwr/gsa-d1-v.kicad_pcb

Board: 2 copper layers, 73.7 x 49.5 mm, 20 parts (0 on the bottom side), 5 nets.

Parts:
BR501: BRIDGE; BR-SIL
C501, C502: 4700u; ELEC22R
D501, D502, D503, D504: DIODE; RECT5
H501, H502, H503, H504: HOLE; HOLE33
J501: CONN-4; SCREW4
J502, J504, J505: CONN-3; SCREW3
J503, J506: CONN-2; SCREW2
J507: CONN-3; MOLEX3
R501, R502: 2.7k; RES10

Connections:
/AC1: BR501.a2, D501.k, D503.a, J501.4
/AC2: BR501.a1, D502.k, D504.a, J501.1
/V+: BR501.d2, C501.2, D503.k, D504.k, J502.3, J507.3, R501.2
/V-: BR501.d1, C502.1, D501.a, D502.a, J502.1, J507.1, R502.1
GND: C501.1, C502.2, J501.2, J501.3, J502.2, J503.1, J503.2, J504.1, J504.2, J504.3, J505.1, J505.2, J505.3, J506.1, J506.2, J507.2, R501.1, R502.2

## KiCad design s-inp/gsa-d1-s.kicad_pcb

Parts:
C201: 100n; CAP725
C202: 1n; CAP-C25
C203: 10u; ELEC4R
D201, D202, D203, D204, D205: LED; LED3
H201, H202: HOLE; HOLE33
J201, J203: CONN-2; MOLEX2
J202: CONN-4; MOLEX4
Q201, Q202, Q203, Q204, Q205: 2N7000; TO92F-SGD
R201: 100k; RES10
R202, R203: 10k; RES10
R204: 560R; RES10
SW201, SW202, SW203, SW204, SW205: SW-PUSH; SW-TACT-ALL
U201: 4093; DIL14
U202: 4017; DIL16

Connections:
/A: J202.1, Q202.g (G), SW202.1, U202.2 (Q1)
/B: J202.2, Q203.g (G), SW203.1, U202.4 (Q2)
/C: J202.3, Q204.g (G), SW204.1, U202.5 (Q6)
/Clock: R202.1, U201.3 (J), U202.13 (~CI)
/D: J202.4, Q205.g (G), SW205.1, U202.6 (Q7)
/Enable: U201.10 (J), U202.14 (CLK)
/Q: J203.1, U201.11 (J)
/Q0: Q201.g (G), SW201.1, U201.5 (A), U201.6 (B), U202.3 (Q0)
/Reset: C203.1 (-), R203.2, U202.15 (MR)
/V+: C201.2, C203.2 (+), J201.2, R201.2, R204.1, U201.14 (V+), U202.16 (VDD)
/V-: C201.1, C202.1, J201.1, Q201.s (S), Q202.s (S), Q203.s (S), Q204.s (S), Q205.s (S), R203.1, U201.7 (V-), U202.8 (VSS)
/~Q: J203.2, U201.4 (J), U201.12 (A), U201.13 (B)
unnamed: C202.2, R202.2, U201.1 (A), U201.2 (B)
unnamed: D201.a (A), D202.a (A), D203.a (A), D204.a (A), D205.a (A), R204.2
unnamed: D201.k (K), Q201.d (D)
unnamed: D202.k (K), Q202.d (D)
unnamed: D203.k (K), Q203.d (D)
unnamed: D204.k (K), Q204.d (D)
unnamed: D205.k (K), Q205.d (D)
unnamed: R201.1, SW201.2, SW202.2, SW203.2, SW204.2, SW205.2, U201.8 (A), U201.9 (B)

Notes on the sheet:
U201: CD4093BE (Quad Schmitt trigger NAND) U202: CD4017BE (Decade counter) Q20x: 2N7000 or BS170 (Low power switching MOSFET) D20x: LEDs (Approx 2V 20mA) R204: Adjust for supply voltage and LED current
Standby Q/~Q
U201

Board: 2 copper layers, 100.0 x 33.0 mm, 29 parts (10 on the bottom side), 20 nets.

## KiCad design gsa-d1.kicad_pcb

Board: 2 copper layers, 100.0 x 100.0 mm, 94 parts (10 on the bottom side), 67 nets.

Parts:
C201, C301, C304, C305, C408, C409: 100n; CAP725
C202: 1n; CAP-C25
C203: 10u; ELEC4R
C302, C303: 22u; ELEC5R
C401, C402: 2.2u; CAP740
C403, C404: 220p; CAP-C25
C405, C406: 47u; ELEC5R
C407, C410: 100u; ELEC6R
C411, C412: 100n; CAP-7-10
C413, C414: 47u; ELEC4R
D201, D202, D203, D204, D205: LED; LED3
D301, D302: 1N4001; DIODE10
H201, H202, H301, H302, H401, H402: HOLE; HOLE33
J201, J203, J307, J402: CONN-2; MOLEX2
J202, J301: CONN-4; MOLEX4
J302, J303, J304, J305, J306, J308, J403: CONN-3; MOLEX3
J401: CONN-3; SCREW3
J404: CONN-2; SCREW2
JP301, JP302: PAD; PAD07
JP303, JP304: LINK; LINK2
Q201, Q202, Q203, Q204, Q205: 2N7000; TO92F-SGD
R201: 100k; RES10
R202, R203, R413: 10k; RES10
R204: 560R; RES10
R301, R302: 4.7k; RES10
R401: 5R6; RES10
R402, R405: 47k; RES10
R403, R404, R406, R407, R408, R410: 1k; RES10
R409, R411: 39k; RES10
R412, R415: 4R7; RES12
R414: 18k; RES10
SW201, SW202, SW203, SW204, SW205: SW-PUSH; SW-TACT-ALL
U201: 4093; DIL14
U202: 4017; DIL16
U301, U302: 4066; DIL14
U303: 7905; REG79
U304: 7805; REG78
U401: LM1876; TO220-15
VR301: 22k; POT-OMEG
VR302: 100k; POT-DUAL

Connections:
/A: J202.1, Q202.g, SW202.1, U202.2
/B: J202.2, Q203.g, SW203.1, U202.4
/C: J202.3, Q204.g, SW204.1, U202.5
/Clock: R202.1, U201.3, U202.13
/D: J202.4, Q205.g, SW205.1, U202.6
/Enable: U201.10, U202.14
/Inputs and Pre-Amp/A: J301.1, U302.12, U302.13
/Inputs and Pre-Amp/A-L: J303.3, U302.1
/Inputs and Pre-Amp/A-R: J303.1, U302.11
/Inputs and Pre-Amp/B: J301.2, U302.5, U302.6
/Inputs and Pre-Amp/B-L: J304.3, U302.4
/Inputs and Pre-Amp/B-R: J304.1, U302.8
/Inputs and Pre-Amp/C: J301.3, U301.12, U301.13
/Inputs and Pre-Amp/C-L: J305.3, U301.1
/Inputs and Pre-Amp/C-R: J305.1, U301.11
/Inputs and Pre-Amp/D: J301.4, U301.5, U301.6
/Inputs and Pre-Amp/D-L: J306.3, JP303.2, U301.4
/Inputs and Pre-Amp/D-R: J306.1, JP304.2, U301.8
/Inputs and Pre-Amp/GND-P: C302.1, C303.2, C304.1, C305.2, D301.a, D302.k, J302.2, U303.1, U304.2
/Inputs and Pre-Amp/GND-S: J303.2, J304.2, J305.2, J306.2, J308.2, JP301.0, JP302.0, VR301.2, VR302.1, VR302.4
/Inputs and Pre-Amp/L: JP303.1, U301.2, U301.3, U302.2, U302.3, VR302.6
/Inputs and Pre-Amp/L-Out: J308.3, R301.1, VR302.5
/Inputs and Pre-Amp/R: JP304.1, U301.9, U301.10, U302.9, U302.10, VR302.3
/Inputs and Pre-Amp/R-Out: J308.1, R302.2, VR302.2
/Inputs and Pre-Amp/V+: C301.2, C304.2, D301.k, J307.2, U301.14, U302.14, U304.3
/Inputs and Pre-Amp/V-: C301.1, C305.1, D302.a, J307.1, U301.7, U302.7, U303.3
/Inputs and Pre-Amp/Vin+: C302.2, J302.3, U304.1
/Inputs and Pre-Amp/Vin-: C303.1, J302.1, U303.2
/Power Amp/GND-S: C403.2, C404.2, C405.1, C406.1, J403.2, R401.2, R402.2, R405.2
/Power Amp/L-In: C401.1, J403.3
/Power Amp/L-Out: J404.2, R409.2, R412.2, U401.3
/Power Amp/MT: C414.2, R414.2, U401.6, U401.11
/Power Amp/R-In: C402.1, J403.1
/Power Amp/R-Out: J404.1, R411.2, R415.2, U401.1
/Power Amp/SB: C413.2, R413.1, U401.9, U401.14
/Power Amp/Standby: J402.1, R413.2
/Power Amp/V+: C407.2, C408.1, J401.3, U401.2, U401.15
/Power Amp/V-: C409.1, C410.1, J401.1, R414.1, U401.4
/Q: J203.1, U201.11
/Q0: Q201.g, SW201.1, U201.5, U201.6, U202.3
/Reset: C203.1, R203.2, U202.15
/V+: C201.2, C203.2, J201.2, R201.2, R204.1, U201.14, U202.16
/V-: C201.1, C202.1, J201.1, Q201.s, Q202.s, Q203.s, Q204.s, Q205.s, R203.1, U201.7, U202.8
/~Q: J203.2, U201.4, U201.12, U201.13
GND: C407.1, C408.2, C409.2, C410.2, C411.2, C412.2, C413.1, C414.1, J401.2, R401.1, U401.5, U401.10
unnamed: C202.2, R202.2, U201.1, U201.2
unnamed: C401.2, R403.1
unnamed: C402.2, R404.1
unnamed: C403.1, R402.1, R403.2, R408.1
unnamed: C404.1, R404.2, R405.1, R410.1
unnamed: C405.2, R406.2
unnamed: C406.2, R407.2
unnamed: C411.1, R415.1
unnamed: C412.1, R412.1
unnamed: D201.a, D202.a, D203.a, D204.a, D205.a, R204.2
unnamed: D201.k, Q201.d
unnamed: D202.k, Q202.d
unnamed: D203.k, Q203.d
unnamed: D204.k, Q204.d
unnamed: D205.k, Q205.d
unnamed: R201.1, SW201.2, SW202.2, SW203.2, SW204.2, SW205.2, U201.8, U201.9
unnamed: R301.2, VR301.3
unnamed: R302.1, VR301.1
unnamed: R406.1, R409.1, U401.7
unnamed: R407.1, R411.1, U401.12
unnamed: R408.2, U401.8
unnamed: R410.2, U401.13

## KiCad design v000/gsa-d1-v000.kicad_pcb

Parts:
BR501: BRIDGE; BR-SIL
C501, C502: 4700u; ELEC22R
D501, D502, D503, D504: DIODE; DIODE5
H501, H502, H503, H504: HOLE; HOLE33
J501: CONN-4; SCREW4
J502, J504, J505: CONN-3; SCREW3
J503, J506: CONN-2; SCREW2
J507: CONN-3; MOLEX3
R501, R502: 2.7k; RES10

Connections:
/AC1: BR501.A2, D501.K, D503.A, J501.4
/AC2: BR501.A1, D502.K, D504.A, J501.1
/V+: BR501.D1, C501.1, D503.K, D504.K, J502.3, J507.3, R501.2
/V-: BR501.D2, C502.2, D501.A, D502.A, J502.1, J507.1, R502.1
GND: C501.2, C502.1, J501.2, J501.3, J502.2, J503.1, J503.2, J504.1, J504.2, J504.3, J505.1, J505.2, J505.3, J506.1, J506.2, J507.2, R501.1, R502.2

Notes on the sheet:
V+ GND V-
Power for Amplifier
Power for Switching Logic
GND GND
Ground Returns
GND GND GND
Use either a bridge rectifier or 4 separate rectifier diodes.

Board: 2 copper layers, 73.7 x 49.5 mm, 20 parts (0 on the bottom side), 5 nets.

## KiCad design c000/gsa-d1-c000.kicad_pcb

Board: 2 copper layers, 99.7 x 33.0 mm, 29 parts (0 on the bottom side), 24 nets.

Parts:
C301, C304, C305: 100n; CAP725
C302, C303: 22u; ELEC5R
D301, D302: 1N4001; DIODE10
H301, H302: HOLE; HOLE33
J301: CONN-4; MOLEX4
J302, J303, J304, J305, J306, J308: CONN-3; MOLEX3
J307: CONN-2; MOLEX2
PAD-S: VAL**; PAD-S
PAD-S#2: VAL**; PAD-S
R301, R302: 4.7k; RES10
U301, U302: 4066; DIL14
U303: 7905; REG79
U304: 7805; REG78
VR301: 22k; POT-OMEG
VR302: 100k; POT-DUAL
X301, X302: LINK; LINK2

Connections:
/A: J301.4, U302.12, U302.13
/A-L: J303.1, U302.1
/A-R: J303.3, U302.11
/B: J301.3, U302.5, U302.6
/B-L: J304.1, U302.4
/B-R: J304.3, U302.8
/C: J301.2, U301.12, U301.13
/C-L: J305.1, U301.1
/C-R: J305.3, U301.11
/D: J301.1, U301.5, U301.6
/D-L: J306.1, U301.4, X301.1
/D-R: J306.3, U301.8, X302.1
/GND-P: C302.2, C303.1, C304.2, C305.1, D301.A, D302.K, J302.2, U303.1, U304.2
/GND-S: J303.2, J304.2, J305.2, J306.2, J308.2, PAD-S.1, PAD-S#2.1, VR301.2, VR302.1, VR302.4
/L: U301.2, U301.3, U302.2, U302.3, VR302.6, X301.2
/L-Out: J308.1, R301.1, VR302.5
/R: U301.9, U301.10, U302.9, U302.10, VR302.3, X302.2
/R-Out: J308.3, R302.2, VR302.2
/V+: C301.1, C304.1, D301.K, J307.2, U301.14, U302.14, U304.3
/V-: C301.2, C305.2, D302.A, J307.1, U301.7, U302.7, U303.3
/Vin+: C302.1, J302.3, U304.1
/Vin-: C303.2, J302.1, U303.2
unnamed: R301.2, VR301.3
unnamed: R302.1, VR301.1

## KiCad design s000/gsa-d1-s000.kicad_pcb

Board: 2 copper layers, 99.7 x 33.0 mm, 29 parts (10 on the bottom side), 20 nets.

Parts:
C201: 100n; CAP725
C202: 1n; CAP-C25
C203: 10u; ELEC4R
D201, D202, D203, D204, D205: LED; LED3
H201, H202: HOLE; HOLE33
J201, J203: CONN-2; MOLEX2
J202: CONN-4; MOLEX4
Q201, Q202, Q203, Q204, Q205: 2N7000; TO92F-SGD
R201: 100k; RES10
R202, R203: 10k; RES10
R204: 560R; RES10
SW201, SW202, SW203, SW204, SW205: SP-PUSH; SW-TACT2
U201: 4093; DIL14
U202: 4017; DIL16

Connections:
/A: J202.4, Q202.G, SW202.1, U202.2
/B: J202.3, Q203.G, SW203.1, U202.4
/C: J202.2, Q204.G, SW204.1, U202.5
/Clock: R202.1, U201.3, U202.13
/D: J202.1, Q205.G, SW205.1, U202.6
/Enable: U201.10, U202.14
/Q: J203.1, U201.11
/Q0: Q201.G, SW201.1, U201.5, U201.6, U202.3
/Reset: C203.2, R203.2, U202.15
/V+: C201.1, C203.1, J201.2, R201.2, R204.1, U201.14, U202.16
/V-: C201.2, C202.2, J201.1, Q201.S, Q202.S, Q203.S, Q204.S, Q205.S, R203.1, U201.7, U202.8
/~Q: J203.2, U201.4, U201.12, U201.13
unnamed: C202.1, R202.2, U201.1, U201.2
unnamed: D201.A, D202.A, D203.A, D204.A, D205.A, R204.2
unnamed: D201.K, Q201.D
unnamed: D202.K, Q202.D
unnamed: D203.K, Q203.D
unnamed: D204.K, Q204.D
unnamed: D205.K, Q205.D
unnamed: R201.1, SW201.2, SW202.2, SW203.2, SW204.2, SW205.2, U201.8, U201.9

## KiCad design p000/gsa-d1-p000.kicad_pcb

Board: 2 copper layers, 99.7 x 33.0 mm, 36 parts (0 on the bottom side), 23 nets.

Parts:
C401, C402: 2.2u; CAP740
C403, C404: 220p; CAP-C25
C405, C406: 47u; ELEC5R
C407, C410: 100u; ELEC6R
C408, C409: 100n; CAP725
C411, C412: 100n; CAP-5-7
C413, C414: 47u; ELEC4R
H401, H402: HOLE; HOLE33
J401: CONN-3; SCREW3
J402: CONN-2; MOLEX2
J403: CONN-3; MOLEX3
J404: CONN-2; SCREW2
R401: 5R6; RES10
R402, R405: 47k; RES10
R403, R404, R406, R407, R408, R410: 1k; RES10
R409, R411: 39k; RES10
R412, R415: 4R7; RES12
R413: 10k; RES10
R414: 18k; RES10
U401: LM1876; TO220-15

Connections:
/GND-S: C403.1, C404.1, C405.2, C406.2, J403.2, R401.2, R402.2, R405.2
/L-In: C401.2, J403.1
/L-Out: J404.1, R409.2, R412.2, U401.3
/MT: C414.1, R414.2, U401.6, U401.11
/R-In: C402.2, J403.3
/R-Out: J404.2, R411.2, R415.2, U401.1
/SB: C413.1, R413.1, U401.9, U401.14
/Standby: J402.2, R413.2
/V+: C407.1, C408.2, J401.1, U401.2, U401.15
/V-: C409.2, C410.2, J401.3, R414.1, U401.4
GND: C407.2, C408.1, C409.1, C410.1, C411.2, C412.2, C413.2, C414.2, J401.2, R401.1, U401.5, U401.10
unnamed: C401.1, R403.1
unnamed: C402.1, R404.1
unnamed: C403.2, R402.1, R403.2, R408.1
unnamed: C404.2, R404.2, R405.1, R410.1
unnamed: C405.1, R406.2
unnamed: C406.1, R407.2
unnamed: C411.1, R415.1
unnamed: C412.1, R412.1
unnamed: R406.1, R409.1, U401.7
unnamed: R407.1, R411.1, U401.12
unnamed: R408.2, U401.8
unnamed: R410.2, U401.13

## Commit log

2018-02-27 GSA Diamond-1 Amplifier
2018-02-28 Combined PCB
2018-03-03 Minor layout improvements to pre-amp controls
2018-03-11 Reduce size of power supply PCB
2019-05-05 Updated to use KiCad v5
2020-10-04 Updated to use gsa-lib v1.1

Notices in the files:
c000/gsa-d1-c000.kicad_pcb:
© Tim Baldwin 2016,2019
GSA-D1-S201  © T J Baldwin 2016,2018
gsa-d1.kicad_pcb:
© Tim Baldwin 2016,2020
GSA-D1-C201  © T J Baldwin 2016,2020
GSA-D1-P201  © T J Baldwin 2016,2020
GSA-D1-S201  © T J Baldwin 2016,2020
p000/gsa-d1-p000.kicad_pcb:
GSA-D1-P200  © T J Baldwin 2016,2018
s000/gsa-d1-s000.kicad_pcb:
GSA-D1-S200  © T J Baldwin 2016,2018
